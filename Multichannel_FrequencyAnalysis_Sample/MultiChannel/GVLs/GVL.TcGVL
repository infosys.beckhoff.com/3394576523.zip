VAR_GLOBAL
	bInvalidateCh4	: BOOL := FALSE;		// Invalidate input signal on channel 4
END_VAR
