TYPE E_AnalysisIDs :
(
	(* Source Id for all channel *)
	eID_Source := 1,
	(* Spectrum Id for all channel *)
	eID_Spectrum,
	(* Sink Id for all channels *)
	eID_Sink
)UDINT;
END_TYPE
